# Keil uVision project uCOS-II.uvproj, settings and files
target FLASH (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: uCOS-II
  c flags: v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\uCOS-II;..\..\uCOS-II\KeilMDK;..\..\BSP;..\..\BSP\OS\uCOS-II;..\..\BSP\ST\STM32F4xx\inc;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\..\..\..\uCOS-II\Source;..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\..\uC-Serial\Driver\ST;..\..\..\..\..\uC-Serial\Driver\ST\STM3240x;..\..\..\..\..\uC-Serial\Line;..\..\..\..\..\uC-Serial\OS;..\..\..\..\..\uC-Serial\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../: app_hooks.c app_serial.c app_serial.h cpu_cfg.h includes.h os_cfg.h stm32f4xx.h stm32f4xx_conf.h
    ./: app_cfg.h lib_cfg.h
    ../../../../../../: app.c
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c stm32f4_discovery.c stm32f4_discovery.h
    ../../BSP/KeilMDK/: cstartup.s
    ../../BSP/OS/uCOS-II/: bsp_os.c bsp_os.h
  group uC/CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../../../../uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-II Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OS-II Port
    ../../../../../uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/Serial
    ../../../../../uC-Serial/Driver/ST/: serial_drv_stm32.c serial_drv_stm32.h
    ../../../../../uC-Serial/Driver/ST/STM3240x/: serial_bsp_stm3240x.c serial_bsp_stm3240x.h
    ../../../../../uC-Serial/Line/: serial_line_dflt.c serial_line_dflt.h serial_line_probe.c serial_line_probe.h serial_line_tty.c serial_line_tty.h
    ../../../../../uC-Serial/OS/: serial_os.h
    ../../../../../uC-Serial/OS/uCOS-II/: serial_os.c
    ../../../../../uC-Serial/Source/: serial.c serial.h serial_buf.c serial_buf.h serial_type.h
  group STM32F4xx Library
    ../../BSP/ST/STM32F4xx/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../BSP/ST/STM32F4xx/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
